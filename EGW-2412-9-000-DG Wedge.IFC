Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Wedge\EGW-2412-9-000-DG Wedge.IFC
Time: 2024-11-05T12:22:05+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 24.2903436863150120; Volume Measure: 0.0242903436863150; Area Measure: 5.9659606555758948

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 24.2903436863150120; Volume Measure: 0.0242903436863150; Area Measure: 5.9659606555758948

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 24.2903436863150120; Volume Measure: 0.0242903436863150; Area Measure: 5.9659606555758948

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGW-2412-9-000-DG Wedge | PSet_Mass_Property - Mass Measure: 24.2903436863150120; Volume Measure: 0.0242903436863150; Area Measure: 5.9659606555758948
EGW-2412-9-000-DG Wedge | SOLIDWORKS Custom Properties - Description: WEDGE; PartNo: EGW-2412-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
