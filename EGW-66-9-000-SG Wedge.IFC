Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Wedge\EGW-66-9-000-SG Wedge.IFC
Time: 2024-11-05T12:22:43+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 3.2022440918728901; Volume Measure: 0.0032022440918729; Area Measure: 0.7447960234617614

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 3.2022440918728901; Volume Measure: 0.0032022440918729; Area Measure: 0.7447960234617614

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 3.2022440918728901; Volume Measure: 0.0032022440918729; Area Measure: 0.7447960234617614

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGW-66-9-000-SG Wedge | PSet_Mass_Property - Mass Measure: 3.2022440918728901; Volume Measure: 0.0032022440918729; Area Measure: 0.7447960234617614
EGW-66-9-000-SG Wedge | SOLIDWORKS Custom Properties - Description: WEDGE; PartNo: EGW-66-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
