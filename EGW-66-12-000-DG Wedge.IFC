Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Wedge\EGW-66-12-000-DG Wedge.IFC
Time: 2024-11-05T12:22:32+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 4.1163227987115958; Volume Measure: 0.0041163227987116; Area Measure: 0.7559415786254385

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 4.1163227987115958; Volume Measure: 0.0041163227987116; Area Measure: 0.7559415786254385

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 4.1163227987115958; Volume Measure: 0.0041163227987116; Area Measure: 0.7559415786254385

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGW-66-12-000-DG Wedge | PSet_Mass_Property - Mass Measure: 4.1163227987115958; Volume Measure: 0.0041163227987116; Area Measure: 0.7559415786254385
EGW-66-12-000-DG Wedge | SOLIDWORKS Custom Properties - Description: WEDGE; PartNo: EGW-66-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
