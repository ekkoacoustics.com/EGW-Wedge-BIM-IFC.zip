Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Wedge\EGW-2412-12-000-DG Wedge.IFC
Time: 2024-11-05T12:21:34+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 32.9303436863148988; Volume Measure: 0.0329303436863149; Area Measure: 5.9875606555758907

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 32.9303436863148988; Volume Measure: 0.0329303436863149; Area Measure: 5.9875606555758907

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 32.9303436863148988; Volume Measure: 0.0329303436863149; Area Measure: 5.9875606555758907

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGW-2412-12-000-DG Wedge | PSet_Mass_Property - Mass Measure: 32.9303436863148988; Volume Measure: 0.0329303436863149; Area Measure: 5.9875606555758907
EGW-2412-12-000-DG Wedge | SOLIDWORKS Custom Properties - Description: WEDGE; PartNo: EGW-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
