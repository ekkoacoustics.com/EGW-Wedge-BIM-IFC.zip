Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Wedge\EGW-66-9-000-DG Wedge.IFC
Time: 2024-11-05T12:22:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 27.3269051884044032; Volume Measure: 0.0273269051884044; Area Measure: 6.7386742076289412

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 27.3269051884044032; Volume Measure: 0.0273269051884044; Area Measure: 6.7386742076289412

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 27.3269051884044032; Volume Measure: 0.0273269051884044; Area Measure: 6.7386742076289412

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGW-66-9-000-DG Wedge | PSet_Mass_Property - Mass Measure: 27.3269051884044032; Volume Measure: 0.0273269051884044; Area Measure: 6.7386742076289412
EGW-66-9-000-DG Wedge | SOLIDWORKS Custom Properties - Description: WEDGE; PartNo: EGW-66-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
