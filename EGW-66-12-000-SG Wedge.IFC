Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Wedge\EGW-66-12-000-SG Wedge.IFC
Time: 2024-11-05T12:22:21+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 38.5401968268560111; Volume Measure: 0.0385401968268560; Area Measure: 6.7679642111558582

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 38.5401968268560111; Volume Measure: 0.0385401968268560; Area Measure: 6.7679642111558582

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 38.5401968268560111; Volume Measure: 0.0385401968268560; Area Measure: 6.7679642111558582

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGW-66-12-000-SG Wedge | PSet_Mass_Property - Mass Measure: 38.5401968268560111; Volume Measure: 0.0385401968268560; Area Measure: 6.7679642111558582
EGW-66-12-000-SG Wedge | SOLIDWORKS Custom Properties - Description: WEDGE; PartNo: EGW-66-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
