Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Wedge\EGW-2812-9-000-DG Wedge.IFC
Time: 2024-11-05T12:21:08+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 28.3200556209144558; Volume Measure: 0.0283200556209145; Area Measure: 6.9615884210246870

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 28.3200556209144558; Volume Measure: 0.0283200556209145; Area Measure: 6.9615884210246870

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 28.3200556209144558; Volume Measure: 0.0283200556209145; Area Measure: 6.9615884210246870

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGW-2812-9-000-DG Wedge | PSet_Mass_Property - Mass Measure: 28.3200556209144558; Volume Measure: 0.0283200556209145; Area Measure: 6.9615884210246870
EGW-2812-9-000-DG Wedge | SOLIDWORKS Custom Properties - Description: WEDGE; PartNo: EGW-2812-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
